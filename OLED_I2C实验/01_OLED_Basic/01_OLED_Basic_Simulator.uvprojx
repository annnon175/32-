# Keil uVision project 01_OLED_Basic_Simulator.uvprojx, settings and files
target 01_OLED_Basic (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(64000000) ELITTLE
  output: 01_OLED_Basic +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Core\Inc;.\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Core/Src/: aht20.c avatar_bitmap.c board.c demo.c font_raw.c gfx_basic.c main.c oled.c system_stm32f1xx.c
  group HAL
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c
  group Startup
    ./startup/: startup_stm32f10x_md.s
