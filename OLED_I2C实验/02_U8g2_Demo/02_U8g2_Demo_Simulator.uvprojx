# Keil uVision project 02_U8g2_Demo_Simulator.uvprojx, settings and files
target 02_U8g2_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(64000000) ELITTLE
  output: 02_U8g2_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER,USE_U8G2
  c misc: --no-multibyte-chars
  c include: .\Core\Inc;.\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Middlewares\U8g2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Core/Src/: aht20.c avatar_bitmap.c board.c demo.c font_lab12.c gfx_u8g2.c main.c oled.c system_stm32f1xx.c u8g2_port.c
  group HAL
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c
  group U8g2
    ./Middlewares/U8g2/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_hvline.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_setup.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_display.c u8x8_gpio.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c u8x8_u8toa.c
  group Startup
    ./startup/: startup_stm32f10x_md.s
